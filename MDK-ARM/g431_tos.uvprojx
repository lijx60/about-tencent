# Keil uVision project g431_tos.uvprojx, settings and files
target g431_tos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: g431_tos +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;..\tencentos\kernel\core\include;..\tencentos\kernel\pm\include;..\tencentos\arch\arm\arm-v7m\common\include;..\tencentos\arch\arm\arm-v7m\cortex-m4\armcc;..\tencentos\TOS＿ＣＯＮＦＩＧ;..\tencentos\osal;..\tencentos\osal\cmsis_os
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c sys.c tim.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_gpio.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_ll_pwr.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group tos_kernel
    ../tencentos/kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos_arch
    ../tencentos/arch/arm/arm-v7m/common/: tos_cpu.c tos_fault.c
    ../tencentos/arch/arm/arm-v7m/cortex-m4/armcc/: port.h port_c.c port_config.h port_s.S
  group tos_config
    ../tencentos/TOS＿ＣＯＮＦＩＧ/: tos_config.h
    ../tencentos/osal/cmsis_os/: cmsis_os.c
    ../tencentos/kernel/pm/: tos_pm.c tos_tickless.c
software components: CMSIS:CORE 4.3.0
